# IAR project Project.ewp, settings and files
configuration STM32L-DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_DMP; MPL_LOG_NDEBUG=1; EMPL; MPU9250; EMPL_TARGET_STM32L
  ICCARM.CCIncludePath2: ..\core\driver\include; ..\core\mllite; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\CMSIS\Include; ..\inc; ..\peripheral; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32L-DISCOVERY; ..\core\driver\eMPL; ..\core\mpl; ..\core\eMPL-hal; ..\core\driver\stm32L
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group core/driver/eMPL
    ../core/driver/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group core/driver/include
    ../core/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
  group core/driver/stm32l
    ../core/driver/stm32L/: log_stm32l.c packet.h
  group core/eMPL-hal
    ../core/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
  group core/mllite
    ../core/mllite/: data_builder.c data_builder.h hal_outputs.c hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
  group core/mpl
    ../core/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h libmpllib.a mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
  group Peripherals
    ../peripheral/: gpio.c i2c.c uart.c
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group STM32L_DISCOVERY
    ../../../Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
  group User
    ../src/: main.c stm32l1xx_it.c system_stm32l1xx.c
